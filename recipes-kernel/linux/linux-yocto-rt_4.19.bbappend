require meta-baldeagle-compat-kernel.inc
