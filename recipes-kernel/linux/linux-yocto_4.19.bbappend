require meta-baldeagle-compat-kernel_4.19.inc
