require meta-baldeagle-compat-kernel_5.4.inc
